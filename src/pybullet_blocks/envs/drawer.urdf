Commit message: quick fix

File: src/pybullet_blocks/envs/drawer.urdf (robot description, URDF)
Before this commit: robot drawer_with_table, 6 links, 5 joints
Joints:
- joint drawer_slide: limit lower=0 upper=0.5 effort=10 velocity=1.0 -> lower=0 upper=1.0 effort=10 velocity=1.0
